# Keil uVision project M7M1.uvprojx, settings and files
target M7M1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: RME +hex
  BeforeMake: copy.bat
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=6 wLevel=3
  c define: STM32F767xx,USE_HAL_DRIVER
  c misc: -Dlikely(x)="__builtin_expect(!!(x), 1)" -Dunlikely(x)="__builtin_expect(!!(x), 0)"
  c include: ..\..\..\M0P0_Library\STM32Cube_FW_F7_V1.11.0\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\..\M0P0_Library\STM32Cube_FW_F7_V1.11.0\Drivers\CMSIS\Include;..\..\MEukaron\Include;..\..\..\M0P0_Library\STM32Cube_FW_F7_V1.11.0\Drivers\STM32F7xx_HAL_Driver\Inc\Conf;..\..\..\M0P0_Library\STM32Cube_FW_F7_V1.11.0\Drivers\CMSIS\Device\ST\STM32F7xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\MEukaron\Include\Platform\CortexM\Chips\STM32F767IG\platform_STM32F767IG.sct
  link misc: --keep=M7M2_Init --keep=VM* --keep=rtthread
  group Kernel
    ../../MEukaron/Kernel/: captbl.c kernel.c kotbl.c pgtbl.c prcthd.c siginv.c
  group Platform
    ../../MEukaron/Platform/CortexM/: platform_cmx.c platform_cmx_asm.s
  group Lib
    ../../../M0P0_Library/STM32Cube_FW_F7_V1.11.0/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_gpio.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_uart.c
    ../../../M0P0_Library/STM32Cube_FW_F7_V1.11.0/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group User
    ../../../M7M2_MuAmmonite/Project/RVMDK-STM32F767IG/Debug/Output/: M7M2_Init.c
    ../../../M5P1_MuProkaron/Project/RVMDK-STM32F767IGT6-RVM/Debug/Output/: VM1.c
    ../../../M5P1(R)_RT-Thread/RVM/rt-thread/bsp/stm32f767-alientek-rvm/: rtthread.c
    ../../../M5P1_MuProkaron/Project/RVMDK-STM32F767IGT6-RVM-DUKTAPE/Debug/Output/: VM_DUKTAPE.c
    ../../../M5P1_MuProkaron/Project/RVMDK-STM32F767IGT6-RVM-LUA/Debug/Output/: VM_LUA.c
  group Linker
    ../../MEukaron/Include/Platform/CortexM/Chips/STM32F767IG/: platform_STM32F767IG.sct
    ../../Documents/: obsolete.txt
