# Keil uVision project M7M1.uvprojx, settings and files
target M7M1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RME +hex
  BeforeMake: copy.bat
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=6 wLevel=3
  c define: STM32F405xx, USE_HAL_DRIVER, HSE_VALUE="8000000", PLL_M="8"
  c include: ..\..\..\M0P0_Library\STM32Cube_FW_F4_V1.21.0\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\MEukaron\Include;..\..\..\M0P0_Library\STM32Cube_FW_F4_V1.21.0\Drivers\CMSIS\Include;..\..\..\M0P0_Library\STM32Cube_FW_F4_V1.21.0\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\M0P0_Library\STM32Cube_FW_F4_V1.21.0\Drivers\STM32F4xx_HAL_Driver\Inc\Conf
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\MEukaron\Include\Platform\CortexM\Chips\STM32F405RG\platform_STM32F405RG.sct
  link misc: --keep=M7M2_Init
  group Kernel
    ../../MEukaron/Kernel/: captbl.c kernel.c kotbl.c pgtbl.c prcthd.c siginv.c
  group Platform
    ../../MEukaron/Platform/CortexM/: platform_cmx.c platform_cmx_asm.s
  group Lib
    ../../../M0P0_Library/STM32Cube_FW_F4_V1.21.0/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../../M0P0_Library/STM32Cube_FW_F4_V1.21.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_gpio.c
  group User
    ../../MEukaron/Benchmark/: benchmark.c benchmark_asm.s
  group Linker
    ../../MEukaron/Include/Platform/CortexM/Chips/STM32F405RG/: platform_STM32F405RG.sct
